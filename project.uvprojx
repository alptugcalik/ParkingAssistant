# Keil uVision project project.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: CONVRT.s DELAY100.s InChar.s main.s OutChar.s OutStr.s Startup.s GPIOINIT_A.s INIT_SSI0.s GPIOINIT_B.s INIT_SCREEN.s WRITE_COMMAND.s WRITE_DISPLAY.s GPIOINIT_F.s WAVE_PROP.s INIT_TIMER1.s READ_ANALOG.s INIT_ADC.s CONVRT_DIGITAL.s GPIOSTEP.s GPIO_ISR.s INIT_TIMER2.s INIT_DISPLAY.s UPDATE_MEAS.s UPDATE_THRE.s UPDATE_OP.s UPDATE_BAR.s DELAY1.s
